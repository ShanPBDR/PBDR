# Keil uVision project pbdr_STM32F4.uvproj, settings and files
target STM32F4 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F405VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: pbdr +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c misc: --C99
  c include: ..\CMSIS;..\STM32F4_DRIVER\inc;..\sdk;..\Hardware\bmi160;..\Hardware\serial;..\Hardware\spi;..\Hardware\timer;..\KernalInc;..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group startup
    ./: startup_stm32f4xx.s
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c stm32f4xx_it.c
  group STM32F4_DRIVER
    ../STM32F4_DRIVER/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group sdk
    ../sdk/: print.c pb_gluelayer.c pb_message.c ubx.c main.c pbdrctrlmgr.c
  group kernal
    ../Kernallib/: lib.lib
  group hardware
    ../Hardware/bmi160/: bmi160.c bmi160_support.c
    ../Hardware/spi/: SPI.c
    ../Hardware/timer/: timer.c
    ../Hardware/serial/: USART2.c USART3.c
